RDEPENDS:packagegroup-base-wifi = "\
    iw \
    wireless-regdb \
    wpa-supplicant"
